# Keil uVision project SensorMeasurements.uvprojx, settings and files
target Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SP49_B21 Infineon
  pack: Infineon.SP49_B2.3.0.4
  cpu: IRAM(0x20000000,0x400) IRAM2(0x30000000,0x100) IROM(0x10000820,0x4BE0) IROM2(0x10000800,0x20) XRAM(0x40000000,0x80000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: SensorMeasurements +hex
  AfterMake: SP49_CRCAdderHex.exe #H -crc16 0x10001400 0x100017FC -crc16 0x10001800 0x100053FC -o  $H@H_withCRC.hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x10000820 size 0x4be0
  memory RVCT5: ROM 0x10000800 size 0x20
  memory RVCT6: RAM 0x40000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x400
  memory RVCT10: RAM 0x30000000 size 0x100
  scatter file: .\ScatterFile.sct
  group Source files
    ./: main.c DevLib.c FIRFilter.h FIRFilter.c
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: SP49_B21 Infineon
  pack: Infineon.SP49_B2.3.0.4
  cpu: as above
  output: SensorMeasurements_Release +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x10000820 size 0x4be0
  memory RVCT5: ROM 0x10000800 size 0x20
  memory RVCT6: ROM 0x40000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x400
  memory RVCT10: RAM 0x30000000 size 0x100
  scatter file: .\ScatterFile.sct
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0, Library:ROMLib 1.2.0
